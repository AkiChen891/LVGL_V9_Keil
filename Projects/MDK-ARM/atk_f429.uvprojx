# Keil uVision project atk_f429.uvprojx, settings and files
target CAN (6190000::V6.19::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f429 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Middlewares;..\..\Drivers;..\..\User;..\..\Middlewares\LVGL;..\..\Middlewares\LVGL\lvgl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
    ../../Drivers/SYSTEM/delay/: delay.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_spi.c stm32f4xx_hal_can.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/CAN/: can.c
    ../../Drivers/BSP/LCD/: lcd.c ltdc.c
    ../../Drivers/BSP/SDRAM/: sdram.c
    ../../Drivers/BSP/TIMER/: btim.c
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/IIC/: myiic.c
  group Middlewares/USMART
    ../../Middlewares/USMART/: usmart.c usmart_config.c usmart_str.c usmart_port.c
  group Readme
    ../../: readme.txt
  group Middlewares/LVGL/Settings
    ../../Middlewares/LVGL/: lv_conf.h lv_port_disp.c lv_port_indev.c
    ../../Middlewares/LVGL/lvgl/src/: lv_init.c
  group Middlewares/LVGL/src/core
    ../../Middlewares/LVGL/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group Middlewares/LVGL/src/display
    ../../Middlewares/LVGL/lvgl/src/display/: lv_display.c
  group Middlewares/LVGL/src/draw
    ../../Middlewares/LVGL/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../../Middlewares/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../../Middlewares/LVGL/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../../Middlewares/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
  group Middlewares/LVGL/src/font
    ../../Middlewares/LVGL/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/LVGL/src/indev
    ../../Middlewares/LVGL/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
  group Middlewares/LVGL/src/layouts
    ../../Middlewares/LVGL/lvgl/src/layouts/flex/: lv_flex.c
    ../../Middlewares/LVGL/lvgl/src/layouts/grid/: lv_grid.c
    ../../Middlewares/LVGL/lvgl/src/layouts/: lv_layout.c
  group Middlewares/LVGL/src/libs
    ../../Middlewares/LVGL/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../../Middlewares/LVGL/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../Middlewares/LVGL/lvgl/src/libs/bmp/: lv_bmp.c
    ../../Middlewares/LVGL/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../../Middlewares/LVGL/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../../Middlewares/LVGL/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../Middlewares/LVGL/lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../../Middlewares/LVGL/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../../Middlewares/LVGL/lvgl/src/libs/libpng/: lv_libpng.c
    ../../Middlewares/LVGL/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../../Middlewares/LVGL/lvgl/src/libs/lz4/: lz4.c
    ../../Middlewares/LVGL/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Middlewares/LVGL/lvgl/src/libs/rle/: lv_rle.c
    ../../Middlewares/LVGL/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../../Middlewares/LVGL/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
  group Middlewares/LVGL/src/misc
    ../../Middlewares/LVGL/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ../../Middlewares/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
  group Middlewares/LVGL/src/osal
    ../../Middlewares/LVGL/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
  group Middlewares/LVGL/src/stdlib
    ../../Middlewares/LVGL/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Middlewares/LVGL/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../Middlewares/LVGL/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../../Middlewares/LVGL/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../../Middlewares/LVGL/lvgl/src/stdlib/: lv_mem.c
  group Middlewares/LVGL/src/others
    ../../Middlewares/LVGL/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../Middlewares/LVGL/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../Middlewares/LVGL/lvgl/src/others/gridnav/: lv_gridnav.c
    ../../Middlewares/LVGL/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../../Middlewares/LVGL/lvgl/src/others/imgfont/: lv_imgfont.c
    ../../Middlewares/LVGL/lvgl/src/others/monkey/: lv_monkey.c
    ../../Middlewares/LVGL/lvgl/src/others/observer/: lv_observer.c
    ../../Middlewares/LVGL/lvgl/src/others/snapshot/: lv_snapshot.c
    ../../Middlewares/LVGL/lvgl/src/others/sysmon/: lv_sysmon.c
    ../../Middlewares/LVGL/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
  group Middlewares/LVGL/src/themes
    ../../Middlewares/LVGL/lvgl/src/themes/default/: lv_theme_default.c
    ../../Middlewares/LVGL/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../Middlewares/LVGL/lvgl/src/themes/simple/: lv_theme_simple.c
    ../../Middlewares/LVGL/lvgl/src/themes/: lv_theme.c
  group Middlewares/LVGL/src/tick
    ../../Middlewares/LVGL/lvgl/src/tick/: lv_tick.c
  group Middlewares/LVGL/src/widgets
    ../../Middlewares/LVGL/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../Middlewares/LVGL/lvgl/src/widgets/arc/: lv_arc.c
    ../../Middlewares/LVGL/lvgl/src/widgets/bar/: lv_bar.c
    ../../Middlewares/LVGL/lvgl/src/widgets/button/: lv_button.c
    ../../Middlewares/LVGL/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Middlewares/LVGL/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Middlewares/LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Middlewares/LVGL/lvgl/src/widgets/chart/: lv_chart.c
    ../../Middlewares/LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Middlewares/LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Middlewares/LVGL/lvgl/src/widgets/image/: lv_image.c
    ../../Middlewares/LVGL/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Middlewares/LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Middlewares/LVGL/lvgl/src/widgets/label/: lv_label.c
    ../../Middlewares/LVGL/lvgl/src/widgets/led/: lv_led.c
    ../../Middlewares/LVGL/lvgl/src/widgets/line/: lv_line.c
    ../../Middlewares/LVGL/lvgl/src/widgets/list/: lv_list.c
    ../../Middlewares/LVGL/lvgl/src/widgets/lottie/: lv_lottie.c
    ../../Middlewares/LVGL/lvgl/src/widgets/menu/: lv_menu.c
    ../../Middlewares/LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Middlewares/LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Middlewares/LVGL/lvgl/src/widgets/property/: lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_style_properties.c lv_textarea_properties.c
    ../../Middlewares/LVGL/lvgl/src/widgets/roller/: lv_roller.c
    ../../Middlewares/LVGL/lvgl/src/widgets/scale/: lv_scale.c
    ../../Middlewares/LVGL/lvgl/src/widgets/slider/: lv_slider.c
    ../../Middlewares/LVGL/lvgl/src/widgets/span/: lv_span.c
    ../../Middlewares/LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Middlewares/LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Middlewares/LVGL/lvgl/src/widgets/switch/: lv_switch.c
    ../../Middlewares/LVGL/lvgl/src/widgets/table/: lv_table.c
    ../../Middlewares/LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Middlewares/LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Middlewares/LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Middlewares/LVGL/lvgl/src/widgets/win/: lv_win.c
  group Middlewares/LVGL/lvgl_app
    ../../Middlewares/LVGL/lvgl_app/: lv_dcbus.c
